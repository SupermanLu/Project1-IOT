# Keil uVision project boot.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: boot
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\HARDWARE\w25q64;..\Shared
  memory RVCT4: ROM 0x8000000 size 0x3000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: boot_main.c w25q64_port_boot.c
    ../HARDWARE/w25q64/: w25q64.c
  group Shared
    ../Shared/: crc32.c flash_param.c flash_ops.c fw_update.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
