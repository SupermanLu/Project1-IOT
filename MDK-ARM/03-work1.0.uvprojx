# Keil uVision project 03-work1.0.uvprojx, settings and files
target 03-work1.0 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: 03-work1_0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../BSP/bsp_debug;../BSP/bsp_delay;../BSP/bsp_adc;../BSP/bsp_key;../HARDWARE/dht11;../HARDWARE/led;../HARDWARE/buzzer;../HARDWARE/mq5;../HARDWARE/light;../HARDWARE/bmp180;../HARDWARE/w25q64;../HARDWARE/LCD;../HARDWARE/LCD/LCD;../HARDWARE/LCD/SPI;..\HARDWARE\infrared;..\HARDWARE\relay;..\APP;..\BSP\bsp_esp;..\Shared
  asm include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../BSP/bsp_debug;../BSP/bsp_delay;../BSP/bsp_adc;../BSP/bsp_key;../HARDWARE/dht11;../HARDWARE/led;../HARDWARE/buzzer;../HARDWARE/mq5;../HARDWARE/light;../HARDWARE/bmp180;../HARDWARE/w25q64;../HARDWARE/LCD;../HARDWARE/LCD/LCD;../HARDWARE/LCD/SPI
  memory RVCT4: ROM 0x8004000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c i2c.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c app_data.c
  group Application/User/BSP
    ../BSP/bsp_debug/: bsp_debug.c
    ../BSP/bsp_delay/: bsp_delay.c
    ../BSP/bsp_adc/: bsp_adc.c
    ../BSP/bsp_key/: bsp_key.c
    ../BSP/bsp_esp/: bsp_esp.c
  group Application/User/HARDWARE
    ../HARDWARE/led/: led.c
    ../HARDWARE/LCD/: gui_page.c page_main.c page_setting.c GUI.c
    ../HARDWARE/buzzer/: buzzer.c
    ../HARDWARE/dht11/: dht11.c
    ../HARDWARE/mq5/: mq5.c
    ../HARDWARE/light/: light.c
    ../HARDWARE/bmp180/: bmp180.c
    ../HARDWARE/LCD/LCD/: lcd.c
    ../HARDWARE/LCD/SPI/: SPI.c
    ../HARDWARE/w25q64/: w25q64.c w25q64_port_app.c
    ../HARDWARE/infrared/: infrared.c ir_decode.c
    ../HARDWARE/relay/: relay.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Applicantion/User/APP
    ../APP/: alarm.c fw_ota.c
  group Shared
    ../Shared/: crc32.c flash_param.c flash_ops.c fw_update.c
software components: CMSIS:CORE 4.3.0
